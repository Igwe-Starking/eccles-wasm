/* kern.inc - heavy arithmetic kernels. The SAME source is compiled to wasm (bench.wasm) and to native code (inside main.c),
 * so the checksums must be bit-identical and the timing ratio is the real cost of the interpreter.
 * No libc, no FMA contraction, no undefined behaviour (all shifts masked, all integer wraps are unsigned). */
#ifndef KERN_INC
#define KERN_INC
#define KINL __attribute__((noinline))
typedef unsigned char ku8; typedef unsigned short ku16; typedef unsigned int ku32; typedef unsigned long long ku64; typedef signed long long ki64;

static ku64 kx_state;
static KINL ku64 kx_next(void) { ku64 s = kx_state; s ^= s >> 12; s ^= s << 25; s ^= s >> 27; kx_state = s; return s * 0x2545F4914F6CDD1Dull; }
static KINL ku32 kx_rand32(void) { return (ku32)(kx_next() >> 32); }
static KINL double kx_unit(void) { return (double)(kx_next() >> 11) * (1.0 / 9007199254740992.0); }       /* [0,1) exactly */
static KINL ku64 kfold(ku64 acc, ku64 v) { acc ^= v + 0x9E3779B97F4A7C15ull + (acc << 6) + (acc >> 2); return acc; }

/* 1. xorshift64* + 64-bit multiply/add mixing (i64 mul/shift/xor throughput) */
static KINL ku64 k_i64mix(ku32 n) {
    ku64 a = 0, b = 1; kx_state = 0x123456789ABCDEF1ull;
    for (ku32 i = 0; i < n; i++) { ku64 v = kx_next(); a += v * (b | 1); b = (b << 13 | b >> 51) ^ v; a = (a << 7 | a >> 57) + (a ^ (v >> 3)); }
    return a ^ b;
}
/* 2. bitwise CRC-32 over a generated byte stream (i32 shifts / xors / branches) */
static KINL ku64 k_crc32(ku32 n) {
    ku32 crc = 0xFFFFFFFFu; kx_state = 0xC0FFEE1234567ull;
    for (ku32 i = 0; i < n; i++) {
        ku32 byte = kx_rand32() & 0xFF; crc ^= byte;
        for (int k = 0; k < 8; k++) crc = (crc >> 1) ^ (0xEDB88320u & (0u - (crc & 1u)));
    }
    return ~crc;
}
/* 3. 64-bit division / remainder / multiplication: Collatz steps + gcd (i64.div_u, i64.rem_u) */
static KINL ku64 k_divrem(ku32 n) {
    ku64 total = 0, g = 0;
    for (ku32 i = 1; i <= n; i++) {
        ku64 x = (ku64)i * 2654435761ull + 12345ull, steps = 0;
        while (x != 1 && steps < 400) { x = (x & 1) ? 3 * x + 1 : x >> 1; steps++; }
        total += steps;
        ku64 p = (ku64)i * 0x9E3779B97F4A7C15ull | 1, q = (ku64)i + 1000003ull;
        while (q) { ku64 t = p % q; p = q; q = t; }
        g += p + (total / (i + 7u));
    }
    return kfold(total, g);
}
/* 4. integer matrix multiply 20x20 (i32 mul/add, memory) */
#define KMN 20
static ku32 km_a[KMN][KMN], km_b[KMN][KMN], km_c[KMN][KMN];
static KINL ku64 k_imatmul(ku32 n) {
    ku64 acc = 0; kx_state = 0xABCDEF0123ull;
    for (ku32 r = 0; r < n; r++) {
        for (int i = 0; i < KMN; i++) for (int j = 0; j < KMN; j++) { km_a[i][j] = kx_rand32() & 0xFFFF; km_b[i][j] = kx_rand32() | 1u; }
        for (int i = 0; i < KMN; i++) for (int j = 0; j < KMN; j++) { ku32 s = 0; for (int k = 0; k < KMN; k++) s += km_a[i][k] * km_b[k][j]; km_c[i][j] = s; }
        for (int i = 0; i < KMN; i++) for (int j = 0; j < KMN; j++) acc = kfold(acc, km_c[i][j]);
    }
    return acc;
}
/* 5. sieve of Eratosthenes (byte memory traffic, branches) */
#define KSV 20000
static ku8 ks_flags[KSV + 1];
static KINL ku64 k_sieve(ku32 n) {
    ku64 acc = 0;
    for (ku32 r = 0; r < n; r++) {
        for (ku32 i = 0; i <= KSV; i++) ks_flags[i] = 1;
        ks_flags[0] = ks_flags[1] = 0;
        for (ku32 i = 2; i * i <= KSV; i++) if (ks_flags[i]) for (ku32 j = i * i; j <= KSV; j += i) ks_flags[j] = 0;
        ku32 cnt = 0; for (ku32 i = 0; i <= KSV; i++) cnt += ks_flags[i];
        acc = kfold(acc, cnt + r);
    }
    return acc;
}
/* 6. sort 1500 pseudo-random u32 with an iterative heap sort (loads/stores/compares), checksum of the sorted order */
#define KSN 1000
static ku32 kh[KSN];
static KINL void k_sift(int start, int end) {
    int root = start;
    while (2 * root + 1 <= end) {
        int child = 2 * root + 1, sw = root;
        if (kh[sw] < kh[child]) sw = child;
        if (child + 1 <= end && kh[sw] < kh[child + 1]) sw = child + 1;
        if (sw == root) return;
        ku32 t = kh[root]; kh[root] = kh[sw]; kh[sw] = t; root = sw;
    }
}
static KINL ku64 k_sort(ku32 n) {
    ku64 acc = 0; kx_state = 0x5EED5EED5EEDull;
    for (ku32 r = 0; r < n; r++) {
        for (int i = 0; i < KSN; i++) kh[i] = kx_rand32();
        for (int s = (KSN - 2) / 2; s >= 0; s--) k_sift(s, KSN - 1);
        for (int e = KSN - 1; e > 0; e--) { ku32 t = kh[0]; kh[0] = kh[e]; kh[e] = t; k_sift(0, e - 1); }
        ku32 bad = 0; for (int i = 1; i < KSN; i++) if (kh[i - 1] > kh[i]) bad++;
        acc = kfold(acc, ((ku64)kh[0] << 32 | kh[KSN - 1]) + bad + kh[KSN / 2]);
    }
    return acc;
}
/* 7. f64: Mandelbrot grid + Newton sqrt + logistic map (IEEE double; no FMA; results compared bit-for-bit) */
static KINL ku64 k_f64(ku32 n) {
    ku64 acc = 0; kx_state = 0xF00D1234ull;
    for (ku32 r = 0; r < n; r++) {
        ku32 inside = 0;
        for (int py = 0; py < 12; py++) for (int px = 0; px < 12; px++) {
            double cr = -2.0 + px * (3.0 / 12.0) + 0.001 * r, ci = -1.2 + py * (2.4 / 12.0), zr = 0, zi = 0; int it = 0;
            while (it < 40 && zr * zr + zi * zi <= 4.0) { double t = zr * zr - zi * zi + cr; zi = 2.0 * zr * zi + ci; zr = t; it++; }
            inside += (ku32)it;
        }
        double x = 0.1 + kx_unit() * 0.8, s = 0;
        for (int i = 0; i < 60; i++) { x = 3.9 * x * (1.0 - x); s += x; }
        double a = 2.0 + kx_unit() * 1000.0, g = a;
        for (int i = 0; i < 30; i++) g = 0.5 * (g + a / g);
        union { double d; ku64 u; } u1, u2, u3; u1.d = s; u2.d = g; u3.d = x;
        acc = kfold(acc, inside); acc = kfold(acc, u1.u); acc = kfold(acc, u2.u); acc = kfold(acc, u3.u);
    }
    return acc;
}
/* 8. f32: 12x12 matrix product + dot products + harmonic sums (single precision, rounding after every operation) */
#define KFN 12
static float kf_a[KFN][KFN], kf_b[KFN][KFN], kf_c[KFN][KFN];
static KINL ku64 k_f32(ku32 n) {
    ku64 acc = 0; kx_state = 0xFACE5678ull;
    for (ku32 r = 0; r < n; r++) {
        for (int i = 0; i < KFN; i++) for (int j = 0; j < KFN; j++) { kf_a[i][j] = (float)((int)(kx_rand32() & 0xFFFF) - 32768) * (1.0f / 4096.0f); kf_b[i][j] = (float)(kx_rand32() & 0xFFFF) * (1.0f / 8192.0f) + 0.125f; }
        for (int i = 0; i < KFN; i++) for (int j = 0; j < KFN; j++) { float s = 0.0f; for (int k = 0; k < KFN; k++) { float p = kf_a[i][k] * kf_b[k][j]; s = s + p; } kf_c[i][j] = s; }
        float tr = 0.0f, h = 0.0f;
        for (int i = 0; i < KFN; i++) tr = tr + kf_c[i][i];
        for (int i = 1; i <= 200; i++) h = h + 1.0f / (float)i;
        union { float f; ku32 u; } a, b, c; a.f = tr; b.f = h; c.f = kf_c[3][7];
        acc = kfold(acc, a.u); acc = kfold(acc, b.u); acc = kfold(acc, c.u);
    }
    return acc;
}
#define KERNEL_LIST(X) X(i64mix, k_i64mix, 1000) X(crc32, k_crc32, 60) X(divrem, k_divrem, 25) X(imatmul, k_imatmul, 1) \
                       X(sieve, k_sieve, 1) X(sort, k_sort, 1) X(f64, k_f64, 1) X(f32, k_f32, 1)
#endif
